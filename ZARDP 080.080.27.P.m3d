# KOMPAS-3D part (ZARDP 080.080.27.P.m3d)

Model tree:
1. Операция без истории:4

Texts:
  ЗАРДП 080.080.27-ХХ.Р
  Кран шаровой фланцевый
  ООО "ИК Энерпред-Ярдос"